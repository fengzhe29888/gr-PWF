<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tlen</value></param>
<param><key>value</key><value>4000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sigmagenfile</value></param>
<param><key>value</key><value>prefix+'/sigmagens/sigmagen_10.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble_2</value></param>
<param><key>value</key><value>2*np.random.random_integers(0,1,size=(tlen,Nt))-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble_1</value></param>
<param><key>value</key><value>2*np.random.random_integers(0,1,size=(tlen,Nt))-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse</value></param>
<param><key>value</key><value>filter.firdes.root_raised_cosine(Q,Q,1,0.35,11*Q)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prewhiten1</value></param>
<param><key>value</key><value>np.linalg.pinv(noise[1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prewhiten0</value></param>
<param><key>value</key><value>np.linalg.pinv(noise[0])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>'/home/zhe/gr-PWF/examples'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_seq_2</value></param>
<param><key>value</key><value>np.multiply(dft_pilot_seq,scramble_2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_seq_1</value></param>
<param><key>value</key><value>np.multiply(dft_pilot_seq,scramble_1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot2file</value></param>
<param><key>value</key><value>prefix+'/pilots/pilot2_4000.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot1file</value></param>
<param><key>value</key><value>prefix+'/pilots/pilot1_4000.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npoints</value></param>
<param><key>value</key><value>max_iteration*interpo</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_hat</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>np.true_divide(np.random.standard_normal(size=(L,Nt,Nt))+np.random.standard_normal(size=(L,Nt,Nt))*1j,np.sqrt(2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_hat</value></param>
<param><key>value</key><value>[np.identity(Nt), np.identity(Nt)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>[np.identity(Nt), np.identity(Nt)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>np.true_divide(np.random.standard_normal(size=(L,Nt,Nt))+np.random.standard_normal(size=(L,Nt,Nt))*1j,np.sqrt(2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_iteration</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interpo</value></param>
<param><key>value</key><value>samp_rate/1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ichn_gain_dB</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_pilot_seq</value></param>
<param><key>value</key><value>np.tile(dft_matrix,(tlen/Nt,1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_matrix</value></param>
<param><key>value</key><value>np.power(dft_coef, np.dot(A.transpose(),A))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_coef</value></param>
<param><key>value</key><value>np.exp(-2*np.pi*1j/Nt)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channelfile</value></param>
<param><key>value</key><value>prefix+'/channels/2x2channel_10dB_3.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel</value></param>
<param><key>value</key><value>np.true_divide(np.random.standard_normal(size=(L,L,Nt,Nt))+np.random.standard_normal(size=(L,L,Nt,Nt))*1j,np.sqrt(2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Q</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pt</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nt</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>L</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>A</value></param>
<param><key>value</key><value>np.arange(Nt)[np.newaxis]</value></param>
</block>
<block>
<key>PWF_channel</key>
<param><key>id</key><value>PWF_channel_0</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>ichn_gain_dB</key><value>ichn_gain_dB</value></param>
<param><key>H</key><value>channel</value></param>
<param><key>is_forward</key><value>True</value></param>
<param><key>noise</key><value>noise</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>channelfile</value></param>
</block>
<block>
<key>PWF_channel</key>
<param><key>id</key><value>PWF_channel_1</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>ichn_gain_dB</key><value>ichn_gain_dB</value></param>
<param><key>H</key><value>channel</value></param>
<param><key>is_forward</key><value>False</value></param>
<param><key>noise</key><value>noise_hat</value></param>
<param><key>rfrom_file</key><value>False</value></param>
<param><key>filename</key><value>channelfile</value></param>
</block>
<block>
<key>PWF_pilot_gen_rx</key>
<param><key>id</key><value>PWF_pilot_gen_rx_0</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot</key><value>pilot_seq_2</value></param>
<param><key>pre_whiten</key><value>prewhiten1</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot2file</value></param>
</block>
<block>
<key>PWF_pilot_gen_rx</key>
<param><key>id</key><value>PWF_pilot_gen_rx_0_0</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot</key><value>pilot_seq_1</value></param>
<param><key>pre_whiten</key><value>prewhiten0</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot1file</value></param>
</block>
<block>
<key>PWF_pilot_gen_tx</key>
<param><key>id</key><value>PWF_pilot_gen_tx_0_0</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot</key><value>pilot_seq_2</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot2file</value></param>
</block>
<block>
<key>PWF_sigmagen</key>
<param><key>id</key><value>PWF_sigmagen_0</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>sigmagenfile</value></param>
</block>
<block>
<key>PWF_weighted_sum_rate</key>
<param><key>id</key><value>PWF_weighted_sum_rate_0</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
<param><key>H</key><value>channel</value></param>
<param><key>ichn_gain_dB</key><value>ichn_gain_dB</value></param>
<param><key>weights</key><value>[1,1]</value></param>
<param><key>T</key><value>[prewhiten0 ,prewhiten1]</value></param>
<param><key>rfrom_file</key><value>False</value></param>
<param><key>filename</key><value>channelfile</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>interp</key><value>interpo</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>interp</key><value>interpo</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>8</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>8</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1_1_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_1_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_2</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_1_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_1_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_2</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"Strong Interference (ichn_gain = 10dB)"</value></param>
<param><key>ylabel</key><value>Weighted Sum-Rate (bits/s/Hz)</value></param>
<param><key>size</key><value>npoints</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>label1</key><value>Dual Link</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value>Identity Sigma</value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_1[:,1]</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_0_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_2[:,1]</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_1_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_2[:,0]</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_0_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_1[:,1]</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_2</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_1[:,0]</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_2[:,0]</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_2[:,1]</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_0</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_1</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>PWF_pilot_receive_rx</key>
<param><key>id</key><value>PWF_pilot_receive_rx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>pre_whiten</key><value>prewhiten0</value></param>
<param><key>pilot_seq</key><value>pilot_seq_1</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen+payload_size</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_0_0</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_1_0</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>PWF_power_adjust</key>
<param><key>id</key><value>PWF_power_adjust_1</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
</block>
<block>
<key>PWF_pilot_receive_rx</key>
<param><key>id</key><value>PWF_pilot_receive_rx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot2file</value></param>
<param><key>pre_whiten</key><value>prewhiten1</value></param>
<param><key>pilot_seq</key><value>pilot_seq_2</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen+payload_size</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>PWF_pilot_receive_rx_sync</key>
<param><key>id</key><value>PWF_pilot_receive_rx_sync_0</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>pre_whiten</key><value>prewhiten0</value></param>
<param><key>pilot_seq</key><value>pilot_seq_1</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>PWF_pilot_receive_rx_sync</key>
<param><key>id</key><value>PWF_pilot_receive_rx_sync_0_0</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot2file</value></param>
<param><key>pre_whiten</key><value>prewhiten1</value></param>
<param><key>pilot_seq</key><value>pilot_seq_2</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>PWF_pilot_receive_tx</key>
<param><key>id</key><value>PWF_pilot_receive_tx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot2file</value></param>
<param><key>pilot_seq</key><value>pilot_seq_2</value></param>
<param><key>NHAT</key><value>noise_hat[1]</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_2</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_2_0</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>PWF_pilot_receive_rx_sync</key>
<param><key>id</key><value>PWF_pilot_receive_rx_sync_0_0_0</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot2file</value></param>
<param><key>pre_whiten</key><value>prewhiten1</value></param>
<param><key>pilot_seq</key><value>pilot_seq_2</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_2_1</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>time_sync</key>
<param><key>id</key><value>time_sync_2_0_0</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>factor</key><value>0</value></param>
<param><key>training_sequence</key><value>0</value></param>
<param><key>Q</key><value>1</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_1_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>PWF_pilot_receive_tx</key>
<param><key>id</key><value>PWF_pilot_receive_tx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>pilot_seq</key><value>pilot_seq_1</value></param>
<param><key>NHAT</key><value>noise_hat[0]</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>PWF_power_adjust</key>
<param><key>id</key><value>PWF_power_adjust_1_0</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
</block>
<block>
<key>PWF_pilot_receive_rx_sync</key>
<param><key>id</key><value>PWF_pilot_receive_rx_sync_0_1</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>pre_whiten</key><value>prewhiten0</value></param>
<param><key>pilot_seq</key><value>pilot_seq_1</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_1_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>loop_bandwidth</key><value>2*np.pi*0.005</value></param>
<param><key>max_freq</key><value>2*np.pi*0.01</value></param>
<param><key>training_sequence</key><value>pilot_seq_1[:,0]</value></param>
</block>
<block>
<key>PWF_debug_printmsg</key>
<param><key>id</key><value>PWF_debug_printmsg_0</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>is_output</key><value>False</value></param>
<param><key>maxit</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/udp</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>8</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>PWF_pilot_gen_tx</key>
<param><key>id</key><value>PWF_pilot_gen_tx_0</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot</key><value>pilot_seq_1</value></param>
<param><key>rfrom_file</key><value>True</value></param>
<param><key>filename</key><value>pilot1file</value></param>
</block>
<connection><source_block_id>PWF_channel_0</source_block_id><sink_block_id>blocks_vector_to_streams_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_channel_0</source_block_id><sink_block_id>blocks_vector_to_streams_1_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_channel_1</source_block_id><sink_block_id>blocks_vector_to_streams_1_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_channel_1</source_block_id><sink_block_id>blocks_vector_to_streams_1_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_debug_printmsg_0</source_block_id><sink_block_id>PWF_pilot_gen_tx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_gen_rx_0</source_block_id><sink_block_id>blocks_vector_to_streams_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_gen_rx_0_0</source_block_id><sink_block_id>blocks_vector_to_streams_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_gen_tx_0_0</source_block_id><sink_block_id>blocks_vector_to_streams_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_tx_0</source_block_id><sink_block_id>PWF_power_adjust_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_tx_0_0</source_block_id><sink_block_id>PWF_power_adjust_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_power_adjust_1</source_block_id><sink_block_id>PWF_pilot_gen_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_power_adjust_1</source_block_id><sink_block_id>PWF_pilot_gen_rx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_power_adjust_1_0</source_block_id><sink_block_id>blocks_streams_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_power_adjust_1_0</source_block_id><sink_block_id>blocks_streams_to_vector_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PWF_sigmagen_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_sigmagen_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PWF_weighted_sum_rate_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_weighted_sum_rate_0</source_block_id><sink_block_id>blocks_repeat_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>blocks_udp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0_0</source_block_id><sink_block_id>blocks_udp_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_0_0</source_block_id><sink_block_id>PWF_channel_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1_0_0</source_block_id><sink_block_id>PWF_pilot_receive_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1_1</source_block_id><sink_block_id>PWF_pilot_receive_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_2</source_block_id><sink_block_id>PWF_channel_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_1</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>PWF_debug_printmsg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>PWF_weighted_sum_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>PWF_debug_printmsg_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>PWF_weighted_sum_rate_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1_0</source_block_id><sink_block_id>fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1_1</source_block_id><sink_block_id>fir_filter_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_1_1</source_block_id><sink_block_id>fir_filter_xxx_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_2</source_block_id><sink_block_id>interp_fir_filter_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_2</source_block_id><sink_block_id>interp_fir_filter_xxx_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>phase_corrector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>phase_corrector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>phase_corrector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>phase_corrector_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_1</source_block_id><sink_block_id>phase_corrector_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_1</source_block_id><sink_block_id>phase_corrector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_1_0</source_block_id><sink_block_id>phase_corrector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_2</source_block_id><sink_block_id>phase_corrector_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_1_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_1_1</source_block_id><sink_block_id>blocks_streams_to_vector_1_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_2</source_block_id><sink_block_id>blocks_streams_to_vector_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_corrector_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_1_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_2</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_0_0</source_block_id><sink_block_id>time_sync_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_1_0</source_block_id><sink_block_id>time_sync_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_1</source_block_id><sink_block_id>time_sync_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_2</source_block_id><sink_block_id>time_sync_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0</source_block_id><sink_block_id>time_sync_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0</source_block_id><sink_block_id>time_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_1</source_block_id><sink_block_id>time_sync_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_0</source_block_id><sink_block_id>time_sync_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_rx_0_0</source_block_id><sink_block_id>PWF_power_adjust_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_rx_0</source_block_id><sink_block_id>PWF_power_adjust_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>time_sync_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>time_sync_1</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1</source_block_id><sink_block_id>PWF_pilot_receive_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_rx_sync_0</source_block_id><sink_block_id>PWF_power_adjust_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>time_sync_0_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>time_sync_1_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_rx_sync_0_0</source_block_id><sink_block_id>PWF_power_adjust_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>time_sync_2</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>time_sync_2_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1_0_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_rx_sync_0_0_0</source_block_id><sink_block_id>PWF_power_adjust_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>time_sync_2_1</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>time_sync_2_0_0</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1_1</source_block_id><sink_block_id>PWF_pilot_receive_rx_sync_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_rx_sync_0_1</source_block_id><sink_block_id>PWF_power_adjust_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_0</source_block_id><sink_block_id>PWF_channel_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1</source_block_id><sink_block_id>PWF_channel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_streams_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_1_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_1_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_gen_tx_0</source_block_id><sink_block_id>blocks_vector_to_streams_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_debug_printmsg_0</source_block_id><sink_block_id>PWF_pilot_gen_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
