<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>A</value></param>
<param><key>value</key><value>np.arange(Nt)[np.newaxis]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>L</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nt</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pt</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Q</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel</value></param>
<param><key>value</key><value>np.true_divide(np.random.standard_normal(size=(L,L,Nt,Nt))+np.random.standard_normal(size=(L,L,Nt,Nt))*1j,np.sqrt(2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_coef</value></param>
<param><key>value</key><value>np.exp(-2*np.pi*1j/Nt)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_matrix</value></param>
<param><key>value</key><value>np.power(dft_coef, np.dot(A.transpose(),A))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_pilot_seq</value></param>
<param><key>value</key><value>np.tile(dft_matrix,(tlen/Nt,1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_delta</value></param>
<param><key>value</key><value>2750</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gap</value></param>
<param><key>value</key><value>6000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ichn_gain_dB</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_iteration</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>[np.identity(Nt), np.identity(Nt)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_hat</value></param>
<param><key>value</key><value>[np.identity(Nt), np.identity(Nt)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot00</value></param>
<param><key>value</key><value>np.array([0.0027,-0.0027,0.0048,-0.0048,0.0066,-0.0066,0.0081,-0.0081,0.0092,-0.0092,0.0097,-0.0097,0.0096,-0.0096,0.0088,-0.0088,0.0075,-0.0075,0.0056,-0.0056,0.0032,-0.0032,0.0005,-0.0005,-0.0024,0.0024,-0.0052,0.0052,-0.0078,0.0078,-0.0100,0.0100,-0.0088,0.0143,-0.0077,0.0172,-0.0060,0.0192,-0.0037,0.0199,-0.0011,0.0194,0.0018,0.0176,0.0046,0.0145,0.0073,0.0104,0.0095,0.0054,0.0111,-0.0000,0.0120,-0.0056,0.0119,-0.0110,0.0109,-0.0156,0.0089,-0.0193,0.0060,-0.0216,0.0023,-0.0222,0.0007,-0.0239,-0.0019,-0.0230,-0.0048,-0.0203,-0.0078,-0.0158,-0.0106,-0.0099,-0.0130,-0.0028,-0.0148,0.0050,-0.0159,0.0127,-0.0159,0.0199,-0.0147,0.0259,-0.0123,0.0299,-0.0087,0.0316,-0.0038,0.0304,0.0021,0.0261,0.0088,0.0187,0.0161,0.0084,0.0262,-0.0017,0.0354,-0.0143,0.0435,-0.0281,0.0501,-0.0421,0.0545,-0.0552,0.0562,-0.0664,0.0547,-0.0745,0.0497,-0.0783,0.0411,-0.0768,0.0289,-0.0694,0.0133,-0.0555,-0.0051,-0.0351,-0.0258,-0.0084,-0.0478,0.0238,-0.0702,0.0603,-0.0918,0.0994,-0.1140,0.1363,-0.1320,0.1722,-0.1453,0.2037,-0.1523,0.2282,-0.1518,0.2432,-0.1428,0.2460,-0.1245,0.2345,-0.0964,0.2067,-0.0583,0.1612,-0.0104,0.0976,0.0467,0.0157,0.1123,-0.0833,0.1851,-0.1978,0.2637,-0.3250,0.3465,-0.4615,0.4318,-0.6030,0.5203,-0.7475,0.6069,-0.8862,0.6903,-1.0141,0.7688,-1.1256,0.8408,-1.2153,0.9051,-1.2781,0.9607,-1.3098,1.0072,-1.3071,1.0444,-1.2680,1.0724,-1.1915,1.0916,-1.0783,1.1030,-0.9303,1.1075,-0.7512,1.1063,-0.5458,1.1007,-0.3202,1.0918,-0.0816,1.0837,0.1595,1.0740,0.3980,1.0641,0.6249,1.0545,0.8319,1.0455,1.0113,1.0372,1.1561,1.0296,1.2607,1.0222,1.3207,1.0148,1.3333,1.0068,1.2976,0.9978,1.2143,0.9875,1.0861,0.9756,0.9174,0.9620,0.7142,0.9469,0.4839,0.9308,0.2349,0.9116,-0.0262,0.8936,-0.2863,0.8774,-0.5362,0.8644,-0.7664,0.8559,-0.9681,0.8534,-1.1336,0.8580,-1.2567,0.8708,-1.3326,0.8922,-1.3585,0.9224,-1.3337,0.9612,-1.2592,1.0075,-1.1380,1.0600,-0.9749,1.1165,-0.7763,1.1746,-0.5499,1.2313,-0.3043])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot01</value></param>
<param><key>value</key><value>pilot00[::16*dec/Q]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot02</value></param>
<param><key>value</key><value>np.array([-0.0027,-0.0027,-0.0048,-0.0048,-0.0066,-0.0066,-0.0081,-0.0081,-0.0092,-0.0092,-0.0097,-0.0097,-0.0096,-0.0096,-0.0088,-0.0088,-0.0075,-0.0075,-0.0056,-0.0056,-0.0032,-0.0032,-0.0005,-0.0005,0.0024,0.0024,0.0052,0.0052,0.0078,0.0078,0.0100,0.0100,0.0088,0.0088,0.0077,0.0077,0.0060,0.0060,0.0037,0.0037,0.0011,0.0011,-0.0018,-0.0018,-0.0046,-0.0046,-0.0073,-0.0073,-0.0095,-0.0095,-0.0111,-0.0111,-0.0120,-0.0120,-0.0119,-0.0119,-0.0109,-0.0109,-0.0089,-0.0089,-0.0060,-0.0060,-0.0023,-0.0023,0.0048,0.0048,0.0115,0.0115,0.0180,0.0180,0.0240,0.0240,0.0289,0.0289,0.0324,0.0324,0.0340,0.0340,0.0335,0.0335,0.0308,0.0308,0.0258,0.0258,0.0187,0.0187,0.0096,0.0096,-0.0009,-0.0009,-0.0125,-0.0125,-0.0244,-0.0244,-0.0360,-0.0360,-0.0494,-0.0439,-0.0603,-0.0508,-0.0687,-0.0555,-0.0738,-0.0576,-0.0750,-0.0567,-0.0720,-0.0526,-0.0646,-0.0454,-0.0528,-0.0351,-0.0370,-0.0220,-0.0177,-0.0066,0.0043,0.0107,0.0280,0.0290,0.0524,0.0476,0.0760,0.0656,0.0977,0.0822,0.1162,0.0963,0.1275,0.1044,0.1341,0.1091,0.1344,0.1092,0.1279,0.1043,0.1144,0.0939,0.0938,0.0780,0.0664,0.0565,0.0324,0.0293,-0.0074,-0.0033,-0.0524,-0.0412,-0.1017,-0.0841,-0.1544,-0.1315,-0.2098,-0.1832,-0.2669,-0.2388,-0.3253,-0.2977,-0.3842,-0.3597,-0.4406,-0.4270,-0.4978,-0.4958,-0.5553,-0.5662,-0.6131,-0.6375,-0.6718,-0.7091,-0.7315,-0.7804,-0.7926,-0.8507,-0.8554,-0.9193,-0.9197,-0.9853,-0.9853,-1.0481,-1.0517,-1.1066,-1.1179,-1.1601,-1.1828,-1.2075,-1.2448,-1.2480,-1.3018,-1.2806,-1.3519,-1.3043,-1.3953,-1.3156,-1.4262,-1.3172,-1.4427,-1.3076,-1.4423,-1.2866,-1.4229,-1.2538,-1.3827,-1.2091,-1.3205,-1.1524,-1.2358,-1.0840,-1.1288,-1.0041,-1.0003,-0.9132,-0.8521,-0.8121,-0.6867,-0.7015,-0.5073,-0.5826,-0.3179,-0.4563,-0.1228,-0.3239,0.0732,-0.1869,0.2622,-0.0439,0.4428,0.1001,0.6095,0.2441,0.7579,0.3863,0.8840,0.5250,0.9846,0.6585,1.0571,0.7853,1.0998,0.9039,1.1119,1.0128,1.0933,1.1109,1.0450,1.1971,0.9687,1.2705,0.8668,1.3304,0.7425,1.3763,0.5992,1.4078,0.4409,1.4249]&#13;)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot03</value></param>
<param><key>value</key><value>pilot02[::16*dec/Q]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot1</value></param>
<param><key>value</key><value>np.array([1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1,1,1,-1,1,1,-1,-1,-1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot1_old</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>np.array([1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,-1,-1,-1,1,-1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,1,1,1,-1,1,1,1,-1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1,-1,-1,-1,1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,-1,1,1,-1,1,1,1,1,-1,1,1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,-1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot2</value></param>
<param><key>value</key><value>np.array([1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,-1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot2_old</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>np.array([1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,-1,1,1,1,1,-1,1,1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,1,-1,1,1,-1,1,-1,-1,1,-1,1,1,1,-1,1,1,1,-1,-1,-1,1,-1,1,1,1,-1,1,1,-1,1,1,1,-1,1,-1,-1,1,-1,1,1,1,-1,-1,-1,1,-1,1,1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1,-1,-1,1,-1,1,1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,1,-1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,-1,-1,1,-1,-1,-1,-1,1,1,1,1,-1,1,1,-1,1,-1,-1,1,-1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot3</value></param>
<param><key>value</key><value>np.array([1,-1,1,1,1,-1,1,1,-1,-1,1,-1,1,-1,-1,-1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot4</value></param>
<param><key>value</key><value>np.array([-1,-1,-1,-1,1,1,-1,1,-1,-1,1,-1,-1,1,-1,1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_seq_1</value></param>
<param><key>value</key><value>np.multiply(dft_pilot_seq,scramble_1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_seq_2</value></param>
<param><key>value</key><value>np.multiply(dft_pilot_seq,scramble_2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>'/home/zhe/gr-PWF/examples'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prewhiten0</value></param>
<param><key>value</key><value>np.linalg.pinv(noise[0])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prewhiten1</value></param>
<param><key>value</key><value>np.linalg.pinv(noise[1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse</value></param>
<param><key>value</key><value>filter.firdes.root_raised_cosine(Q,Q,1,0.35,11*Q)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1, eb, nfilts*11*4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble_1</value></param>
<param><key>value</key><value>2*np.random.random_integers(0,1,size=(tlen,Nt))-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble_2</value></param>
<param><key>value</key><value>2*np.random.random_integers(0,1,size=(tlen,Nt))-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sigmagenfile</value></param>
<param><key>value</key><value>prefix+'/sigmagens/sigmagen_10.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>samp_rate/Q</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tlen</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>3400000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>PWF_ML_frame_sync</key>
<param><key>id</key><value>PWF_ML_frame_sync_0</value></param>
<param><key>nt</key><value>2</value></param>
<param><key>pilot_length</key><value>tlen*Q/dec</value></param>
<param><key>pilot</key><value>pilot01.reshape(tlen*Q/dec,2)</value></param>
<param><key>rho</key><value>0.3</value></param>
</block>
<block>
<key>PWF_ML_frame_sync</key>
<param><key>id</key><value>PWF_ML_frame_sync_0_0</value></param>
<param><key>nt</key><value>2</value></param>
<param><key>pilot_length</key><value>tlen*Q/dec</value></param>
<param><key>pilot</key><value>pilot03.reshape(tlen*Q/dec,2)</value></param>
<param><key>rho</key><value>0.3</value></param>
</block>
<block>
<key>PWF_pilot_gen</key>
<param><key>id</key><value>PWF_pilot_gen_0</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot</key><value>pilot3.reshape(tlen,2)</value></param>
<param><key>rfrom_file</key><value>False</value></param>
</block>
<block>
<key>PWF_pilot_gen</key>
<param><key>id</key><value>PWF_pilot_gen_0_0</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot</key><value>pilot4.reshape(tlen,2)</value></param>
<param><key>rfrom_file</key><value>False</value></param>
</block>
<block>
<key>PWF_pilot_receive</key>
<param><key>id</key><value>PWF_pilot_receive_0_0</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot_seq</key><value>pilot3.reshape(tlen,2)</value></param>
<param><key>rfrom_file</key><value>False</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>PWF_pilot_receive</key>
<param><key>id</key><value>PWF_pilot_receive_0_0_0</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>frame_length</key><value>tlen</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot_seq</key><value>pilot4.reshape(tlen,2)</value></param>
<param><key>rfrom_file</key><value>False</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>PWF_power_adjust</key>
<param><key>id</key><value>PWF_power_adjust_1</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
</block>
<block>
<key>PWF_rx_frame_sync</key>
<param><key>id</key><value>PWF_rx_frame_sync_0_1</value></param>
<param><key>pilot_length</key><value>tlen*Q/dec</value></param>
</block>
<block>
<key>PWF_rx_frame_sync</key>
<param><key>id</key><value>PWF_rx_frame_sync_0_1_0</value></param>
<param><key>pilot_length</key><value>tlen*Q/dec</value></param>
</block>
<block>
<key>PWF_rx_frame_sync</key>
<param><key>id</key><value>PWF_rx_frame_sync_0_1_0_0</value></param>
<param><key>pilot_length</key><value>tlen*Q/dec</value></param>
</block>
<block>
<key>PWF_rx_frame_sync</key>
<param><key>id</key><value>PWF_rx_frame_sync_0_1_1</value></param>
<param><key>pilot_length</key><value>tlen*Q/dec</value></param>
</block>
<block>
<key>PWF_sigmagen</key>
<param><key>id</key><value>PWF_sigmagen_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>sigmagenfile</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>rfrom_file</key><value>False</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/avg2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/matched2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/matched3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_1</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/avg3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_2</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/flag2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_2_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/flag3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/rx12</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/rx11</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_1</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/rx111</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_2</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sync_input</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_3</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/lp11</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_4</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/lp12</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_4_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/deci1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_4_0_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/deci2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_4_0_0_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sig1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_4_0_0_0_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sig2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_4_0_0_1</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/deci4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0_4_0_1</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/deci3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_1_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sig11</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_1_0_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sig12</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sigmaa11</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sigmaa12</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>look_ahead</key><value>6000</value></param>
<param><key>threshold_factor_rise</key><value>20</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>look_ahead</key><value>6000</value></param>
<param><key>threshold_factor_rise</key><value>20</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>gap,tlen*Q</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>lengths</key><value>gap,tlen*Q</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0_0</value></param>
<param><key>lengths</key><value>gap,tlen*Q</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_1</value></param>
<param><key>lengths</key><value>gap,tlen*Q</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(0, 0, 0)</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>Q/dec</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>Q/dec</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>Q/dec</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1_0</value></param>
<param><key>decim</key><value>Q/dec</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_1_0</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_1_0_0</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>symbol_rate</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>symbol_rate*0.1</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>symbol_rate</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>symbol_rate*0.1</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>symbol_rate</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>symbol_rate*0.1</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>cutoff_freq</key><value>symbol_rate</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>symbol_rate*0.1</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>tx_freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.1</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>tx_freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.4</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq-f_delta</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>tx_freq-f_delta</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq-f_delta</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>tx_freq-f_delta</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>PWF_ML_frame_sync_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_ML_frame_sync_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_ML_frame_sync_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_ML_frame_sync_0_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_gen_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_gen_0_0</source_block_id><sink_block_id>blocks_vector_to_streams_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_0_0</source_block_id><sink_block_id>PWF_power_adjust_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_4_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_0_0_0</source_block_id><sink_block_id>PWF_power_adjust_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_4_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_power_adjust_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_power_adjust_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_rx_frame_sync_0_1</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_rx_frame_sync_0_1_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_rx_frame_sync_0_1_0_0</source_block_id><sink_block_id>fir_filter_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_rx_frame_sync_0_1_1</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_sigmagen_0</source_block_id><sink_block_id>PWF_pilot_gen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_sigmagen_0</source_block_id><sink_block_id>PWF_pilot_gen_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>PWF_pilot_gen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>PWF_pilot_gen_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_1</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1</source_block_id><sink_block_id>PWF_ML_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_0</source_block_id><sink_block_id>PWF_ML_frame_sync_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1</source_block_id><sink_block_id>PWF_pilot_receive_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1_1_0</source_block_id><sink_block_id>PWF_pilot_receive_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>interp_fir_filter_xxx_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_4_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_4_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>blocks_streams_to_vector_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_4_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_1_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_1_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_streams_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_1</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_1</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
