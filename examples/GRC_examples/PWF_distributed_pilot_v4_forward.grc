<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>A</value></param>
<param><key>value</key><value>np.arange(Nt)[np.newaxis]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>L</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nt</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pt</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Q</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker</value></param>
<param><key>value</key><value>[-1,-1,-1,-1,-1,1,1,-1,-1,1,-1,1,-1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel</value></param>
<param><key>value</key><value>np.true_divide(np.random.standard_normal(size=(L,L,Nt,Nt))+np.random.standard_normal(size=(L,L,Nt,Nt))*1j,np.sqrt(2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channelfile</value></param>
<param><key>value</key><value>prefix+'/channels/2x2channel_10dB_3.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_coef</value></param>
<param><key>value</key><value>np.exp(-2*np.pi*1j/Nt)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_matrix</value></param>
<param><key>value</key><value>np.power(dft_coef, np.dot(A.transpose(),A))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dft_pilot_seq</value></param>
<param><key>value</key><value>np.tile(dft_matrix,(tlen/Nt,1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ichn_gain_dB</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>[np.identity(Nt), np.identity(Nt)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_hat</value></param>
<param><key>value</key><value>[np.identity(Nt), np.identity(Nt)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>172</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>np.array([1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,-1,-1,-1,1,-1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,1,1,1,-1,1,1,1,-1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1,-1,-1,-1,1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,-1,1,1,-1,1,1,1,1,-1,1,1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,-1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot1</value></param>
<param><key>value</key><value>np.array([1, -1, 1, 1, 1, -1, 1, 1, -1, -1, 1, -1, 1, -1, -1, -1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot1file</value></param>
<param><key>value</key><value>prefix+'/pilots/pilot1_4000.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot2</value></param>
<param><key>value</key><value>np.array([1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,-1,1,1,1,-1,1,1,1,1,-1,1,1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,1,1,1,-1,1,1,-1,1,-1,-1,1,-1,1,1,1,-1,1,1,1,-1,-1,-1,1,-1,1,1,1,-1,1,1,-1,1,1,1,-1,1,-1,-1,1,-1,1,1,1,-1,-1,-1,1,-1,1,1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1,-1,-1,1,-1,1,1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,1,-1,-1,-1,1,-1,1,1,-1,1,1,1,-1,1,-1,-1,1,-1,-1,-1,-1,1,1,1,1,-1,1,1,-1,1,-1,-1,1,-1,-1,-1,1,-1,1,1,-1,1,-1,-1,-1,1,-1,-1,-1,1,1,1,-1,1,-1,-1,1,-1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot2file</value></param>
<param><key>value</key><value>prefix+'/pilots/pilot2_4000.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_seq_1</value></param>
<param><key>value</key><value>np.multiply(dft_pilot_seq,scramble_1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_seq_2</value></param>
<param><key>value</key><value>np.multiply(dft_pilot_seq,scramble_2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>'/home/zhe/gr-PWF/examples'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prewhiten0</value></param>
<param><key>value</key><value>np.linalg.pinv(noise[0])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prewhiten1</value></param>
<param><key>value</key><value>np.linalg.pinv(noise[1])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse</value></param>
<param><key>value</key><value>filter.firdes.root_raised_cosine(Q,Q,1,0.35,11*Q)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble_1</value></param>
<param><key>value</key><value>2*np.random.random_integers(0,1,size=(tlen,Nt))-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scramble_2</value></param>
<param><key>value</key><value>2*np.random.random_integers(0,1,size=(tlen,Nt))-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sigmagenfile</value></param>
<param><key>value</key><value>prefix+'/sigmagens/sigmagen_10.bin'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tlen</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>2400000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>PWF_pilot_gen</key>
<param><key>id</key><value>PWF_pilot_gen_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot</key><value>pilot2.reshape(tlen,2)</value></param>
<param><key>rfrom_file</key><value>False</value></param>
</block>
<block>
<key>PWF_pilot_receive</key>
<param><key>id</key><value>PWF_pilot_receive_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>pilot1file</value></param>
<param><key>frame_length</key><value>tlen+payload_size</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
<param><key>pilot_seq</key><value>pilot1.reshape(tlen,2)</value></param>
<param><key>rfrom_file</key><value>False</value></param>
<param><key>weight</key><value>1</value></param>
</block>
<block>
<key>PWF_power_adjust</key>
<param><key>id</key><value>PWF_power_adjust_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
</block>
<block>
<key>PWF_rx_frame_sync</key>
<param><key>id</key><value>PWF_rx_frame_sync_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
</block>
<block>
<key>PWF_rx_frame_sync</key>
<param><key>id</key><value>PWF_rx_frame_sync_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>pilot_length</key><value>tlen</value></param>
</block>
<block>
<key>PWF_sigmagen</key>
<param><key>id</key><value>PWF_sigmagen_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>sigmagenfile</value></param>
<param><key>nlinks</key><value>L</value></param>
<param><key>rfrom_file</key><value>False</value></param>
<param><key>nt</key><value>Nt</value></param>
<param><key>Pt</key><value>Pt</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/avg2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/matched2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0_1</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/matched1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_1</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/avg1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/flag2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_2_0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/flag1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/rx2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_3_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/rx1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/cut2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_4_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sigma1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_4_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/rex</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/gnuradio_trunk/gnufiles/sigma</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>look_ahead</key><value>tlen*2</value></param>
<param><key>threshold_factor_rise</key><value>20</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0_0_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>look_ahead</key><value>tlen+50</value></param>
<param><key>threshold_factor_rise</key><value>20</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>lengths</key><value>13,128,10000</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1</value></param>
<param><key>lengths</key><value>8,10000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>barker</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>pilot1[0::2]</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>2.5</value></param>
<param><key>noise_voltage</key><value>0.254</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>0.1+0.3j</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>16</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_3_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>np.convolve( pulse, np.kron(pilot1[0::2],(1,)+(len(pulse)-1)*(0,))[:(len(pilot1[0::2])-1)*len(pulse)+1:]  )[::-1]</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_3_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>barker[::-1]</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>Q</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.1</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>30.72e6</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>PWF_pilot_gen_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_pilot_receive_0</source_block_id><sink_block_id>PWF_power_adjust_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_power_adjust_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_rx_frame_sync_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PWF_rx_frame_sync_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>PWF_rx_frame_sync_0_1_0</source_block_id><sink_block_id>blocks_streams_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>PWF_pilot_gen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1</source_block_id><sink_block_id>PWF_pilot_receive_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_4_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_3_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_3_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>PWF_rx_frame_sync_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
